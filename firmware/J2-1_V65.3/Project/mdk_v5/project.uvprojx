# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\drivers\src;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\bsp\inc;..\bsp\src;..\bsp\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group app
    ../bsp/src/: main.c at32f403a_407_int.c at32f403a_407_clock.c
  group bsp
    ../bsp/src/: IOstream.c Initial.c SerialPort.c SPIdrive.c InteriorAD.c simulateIIC.c spiFlash.c GP8211S.c Command.c Function.c Temperature.c Delay.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group readme
    ../: readme.txt
