# Keil uVision project templates.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.3
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templates +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\libraries\drivers\inc;..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\middlewares\CherryRB;..\middlewares\rtthread\bsp;..\middlewares\rtthread\include;..\user;..\user\app;..\user\bsp;..\middlewares\w5500;..\middlewares\w5500\ioLibrary_Driver\Ethernet\W5500;..\middlewares\w5500\ioLibrary_Driver\Ethernet;..\middlewares\w5500\ioLibrary_Driver\Internet\DHCP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../user/: at32f403a_407_clock.c at32f403a_407_int.c main.c
  group app
    ../user/app/: AppInfo.c AppDwin.c AppEth.c AppItla.c AppPort.c AppThread.c AppCmdLine.c AppDut.c
  group bsp
    ../user/bsp/: BspBoard.c BspConfig.c BspDwt.c BspEvent.c BspFlash.c BspKey.c BspSoftiic.c BspUart.c BspCH9434.c BspComPort.c BspBuzzer.c
  group firmware
    ../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
    ../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group cherryrb
    ../middlewares/CherryRB/: chry_ringbuffer.c
  group rtthread
    ../middlewares/rtthread/bsp/: board.c
    ../middlewares/rtthread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../middlewares/rtthread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group w5500
    ../middlewares/w5500/: tcp_server_multi_socket.c wiz_interface.c wiz_platform.c
    ../middlewares/w5500/ioLibrary_Driver/Ethernet/W5500/: w5500.c
    ../middlewares/w5500/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../middlewares/w5500/ioLibrary_Driver/Internet/DHCP/: dhcp.c
